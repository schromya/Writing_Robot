Commit message: Increased simulation hz and fixed table urdf

File: urdfs/writing_surface.urdf (robot description, URDF)
Before this commit: robot simple_table, 5 links, 4 joints
Links:
- link table_top: geometry collision box size=0.5 0.5 0.05; visual box size=0.5 0.5 0.05
